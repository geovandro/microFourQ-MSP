# IAR project microFourQ-MSP.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 5214
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: WIN32; _DEBUG; _CONSOLE; __WINDOWS__; _GENERIC_; __IAR__; USE_ENDO; _NO_CACHE_MEM_; _MSP430_; USE_ASM; BENCH_VERIFY
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../src/: crypto_util.c eccp2.c eccp2_no_endo.c FourQ.h FourQ_api.h FourQ_internal.h FourQ_params.h FourQ_tables.h kex.c main.c schnorrq.c table_lookup.h
  group blake2b
    ../src/blake2b/: blake.c blake.h sph_blake.h sph_types.h
  group MSP430
    ../src/MSP430/: fp.h fpadd1271.s43 fpcopy1271.s43 fpmul1271.s43 fpneg1271.s43 fpsub1271.s43 fpzero1271.s43 mod1271.s43 mod_sqr128.s43 mp_add.s43 mp_add128.s43 mp_mul.s43 mp_sub.s43
  group random
    ../src/random/: random.c random.h
  group tests
    ../src/tests/: crypto_tests.c ecc_tests.c fp_tests.c test_extras.c test_extras.h
